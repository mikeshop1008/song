# Keil uVision project Blinky.uvprojx, settings and files
target Debug (6190000::V6.19::ARMCLANG)
  device: STM32F401VCTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.0
  cpu: IROM(0x08000000,0x40000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Blinky
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32F401xC,HSE_VALUE=8000000
  c include: ..\\Core\\Inc;..\\Drivers\\STM32F4xx_HAL_Driver\\Inc;..\\Drivers\\STM32F4xx_HAL_Driver\\Inc\\Legacy;..\\Drivers\\CMSIS\\Device\\ST\\STM32F4xx\\Include;..\\Drivers\\CMSIS\\Include;..\\MDK-ARM\\RTE\\Device\\STM32F401VCTx
  asm include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20002000 size 0xe000
  memory RVCT10: RAM 0x20000000 size 0x2000
  group Flash OPT
    ./: STM32F401xx_OPT.s
  group Source Files
    ..//Core//Src//: main.c motor.c sensors.c seven_seg.c buzzer.c indicators.c bluetooth.c navigation.c lcd1602.c stm32f4xx_it.c stm32f4xx_hal_msp.c
    ..//Drivers//STM32F4xx_HAL_Driver//Src//: stm32f4xx_hal.c stm32f4xx_hal_cortex.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_exti.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c
  group Documentation
    ./: Abstract.txt
software components: CMSIS:CORE 5.5.0, CMSIS:RTOS2:Keil RTX5 5.5.3, CMSIS:RTOS2:Keil RTX5 5.5.3, Compiler:Event Recorder 1.4.0, Board Support:Buttons 1.0.0, Board Support:LED 1.0.0, Device:STM32Cube Framework:Classic 1.8.1, Device:STM32Cube HAL:Common 1.7.13, Device:STM32Cube HAL:Cortex 1.7.13, Device:STM32Cube HAL:GPIO 1.7.13, Device:STM32Cube HAL:PWR 1.7.13, Device:STM32Cube HAL:RCC 1.7.13, Device:Startup 2.6.3
